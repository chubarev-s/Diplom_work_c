# Keil uVision project program.uvprojx, settings and files
target Target 1 (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: program +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\h-files
  asm include: .\h-files
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group Source Group 1
    ./c-files/: 1636RR52.c init.c interruptions.c main.c MDR1986VE1T_IT.c save_flash.c eth_can.c
software components: Device:Startup 2.0.3, Drivers:CAN 2.0.3, Drivers:DMA 2.0.3, Drivers:EEPROM 2.0.3, Drivers:Ethernet 2.0.3, Drivers:IWDG 2.0.3, Drivers:PORT 2.0.3, Drivers:POWER 2.0.3, Drivers:RST_CLK 2.0.3, Drivers:SSP 2.0.3, Drivers:TIMER 2.0.3
